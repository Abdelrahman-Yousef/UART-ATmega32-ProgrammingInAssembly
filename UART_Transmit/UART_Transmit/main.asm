;
; UART_Transmit.asm
;
; Created: 8/30/2023 5:54:43 PM
; Author : Options
;


; Replace with your application code

.EQU RAM_LOCATION = 0x100


.ORG 0x00
MAIN:

LDI XL,LOW(RAM_LOCATION)
LDI XH,HIGH(RAM_LOCATION)
LDI R16,'Y'
ST X+,R16
LDI R16,'E'
ST X+,R16
LDI R16,'S'
ST X+,R16

LDI R16,0x33
OUT UBRRL,R16
LDI R16,0x00
OUT UBRRH,R16
LDI R16,0x86
OUT UCSRC,R16
LDI R16,0x08
OUT UCSRB,R16

AGAIN:
LDI XL,LOW(RAM_LOCATION)
LDI XH,HIGH(RAM_LOCATION)
LDI R17,0x03

LOOP:
SBIS UCSRA,UDRE
RJMP LOOP

LD R16,X+
OUT UDR,R16
DEC R17
BREQ AGAIN
RJMP LOOP
